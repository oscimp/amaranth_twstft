options:
  parameters:
    generate_options: no_gui
    id: zmq_rx_short
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: duration_in_s
  id: variable
  parameters:
    value: 5*60
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: |-
      x2 complex
      x2 two channels
    file: /data/test.bin
    type: short
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*duration_in_s*2*2)
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'False'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: short
  states: {}

connections:
- [blocks_deinterleave_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_deinterleave_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_deinterleave_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_head_0, '0', blocks_file_sink_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_deinterleave_0, '0']
- [zeromq_sub_source_0, '0', blocks_head_0, '0']
- [zeromq_sub_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
