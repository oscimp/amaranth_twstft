options:
  parameters:
    generate_options: qt_gui
    id: x310_twstft_gr
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_interleaved_short_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32767'
    vector_output: 'False'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /data/fichier.bin
    type: short
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt2/231019_SATRE/1697778719_SATRE_5.0MSps_short_interleaved2.bin
    repeat: 'True'
    type: short
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32767'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e5
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e5
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate/10
    fc: '0'
    fftsize: '16384'
    name: '"squared"'
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    name: '"non squared"'
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '10240'
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    ant1: A
    center_freq0: 70e6
    center_freq1: 70e6
    clock_source0: external
    comment: |-
      "addr0=192.168.10.2" = TWSTFT
      "addr0=192.168.11.2" = GNSS
    dev_addr: '"addr0=192.168.10.2"'
    dev_args: '""'
    gain0: '6'
    gain1: '0'
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    start_time: '5'
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: short
  states: {}

connections:
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_arg_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_interleaved_short_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_interleaved_short_0_0, '0', zeromq_pub_sink_0, '0']
- [blocks_deinterleave_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_deinterleave_0, '0', blocks_multiply_xx_0, '0']
- [blocks_deinterleave_0, '0', blocks_multiply_xx_0, '1']
- [blocks_deinterleave_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_deinterleave_0, '1', blocks_complex_to_arg_0_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_xx_0_0, '1']
- [blocks_deinterleave_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_interleave_0, '0', blocks_complex_to_interleaved_short_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_deinterleave_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_throttle2_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '0', blocks_complex_to_arg_0, '0']
- [uhd_usrp_source_0, '0', blocks_interleave_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '1']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_complex_to_arg_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_interleave_0, '1']
- [uhd_usrp_source_0, '1', blocks_multiply_xx_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_xx_0_0, '1']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0_0, '1']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
